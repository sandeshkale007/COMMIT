# file: LPBAM.ioc
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CONF1.CORTEX_M33_NS.userName=CORTEX_M33
CONF1.GPIO.groupedBy=Group By Peripherals
CONF1.KeepUserPlacement=false
CONF1.LPDMA1.LINKEDLISTMODE_LPDMACH0=DMA_LINKEDLIST_CIRCULAR
CONF1.LPTIM1.Period=LPDP
CONF1.LPTIM1.RepetitionCounter=LPDR
CONF1.MMTAppRegionsCount=0
CONF1.MMTConfigApplied=false
CONF1.Mcu.ContextProject=TrustZoneDisabled
CONF1.Mcu.Family=STM32U5
CONF1.Mcu.IP0=CORTEX_M33_NS
CONF1.Mcu.IP1=ICACHE
CONF1.Mcu.IP10=SYS
CONF1.Mcu.IP2=LPBAM
CONF1.Mcu.IP3=LPBAMQUEUE
CONF1.Mcu.IP4=LPDMA1
CONF1.Mcu.IP5=LPTIM1
CONF1.Mcu.IP6=MEMORYMAP
CONF1.Mcu.IP7=NVIC
CONF1.Mcu.IP8=PWR
CONF1.Mcu.IP9=RCC
CONF1.Mcu.IPNb=11
CONF1.Mcu.Name=STM32U545RETxQ
CONF1.Mcu.Package=LQFP64
CONF1.Mcu.Pin0=PC13
CONF1.Mcu.Pin1=PC14-OSC32_IN (PC14)
CONF1.Mcu.Pin10=VP_LPTIM1_VS_LPTIM_counterModeInternalClock
CONF1.Mcu.Pin11=VP_LPTIM1_VS_CH1
CONF1.Mcu.Pin12=VP_PWR_VS_SECSignals
CONF1.Mcu.Pin13=VP_PWR_VS_LPOM
CONF1.Mcu.Pin14=VP_SYS_VS_Systick
CONF1.Mcu.Pin15=VP_LPBAM_VS_SIG1
CONF1.Mcu.Pin16=VP_LPBAM_VS_SIG4
CONF1.Mcu.Pin17=VP_MEMORYMAP_VS_MEMORYMAP
CONF1.Mcu.Pin2=PC15-OSC32_OUT (PC15)
CONF1.Mcu.Pin3=PC1
CONF1.Mcu.Pin4=PA1
CONF1.Mcu.Pin5=PA5
CONF1.Mcu.Pin6=PB0
CONF1.Mcu.Pin7=VP_ICACHE_VS_ICACHE
CONF1.Mcu.Pin8=VP_LPBAMQUEUE_VS_QUEUE
CONF1.Mcu.Pin9=VP_LPDMA1_VS_LPDMACH0
CONF1.Mcu.PinsNb=18
CONF1.Mcu.ThirdPartyNb=0
CONF1.Mcu.UserName=STM32U545RETxQ
CONF1.NVIC.BusFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.DebugMonitor_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.EXTI13_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF1.NVIC.ForceEnableDMAVector=true
CONF1.NVIC.HardFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.LPDMA1_Channel0_IRQn=true\:0\:0\:false\:false\:true\:true\:true\:true
CONF1.NVIC.MemoryManagement_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.NonMaskableInt_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.PendSV_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
CONF1.NVIC.SVCall_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.NVIC.SysTick_IRQn=true\:15\:0\:false\:false\:true\:false\:true\:false
CONF1.NVIC.UsageFault_IRQn=true\:0\:0\:false\:false\:true\:false\:false\:false
CONF1.PA1.Signal=LPGPIO_Output
CONF1.PA5.GPIO_Label=GREEN
CONF1.PA5.Signal=GPIO_Output
CONF1.PB0.Signal=LPGPIO_Output
CONF1.PC1.Signal=S_LPTIM1_CH1
CONF1.PC13.GPIO_Label=SWITCH
CONF1.PC13.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
CONF1.PC13.Signal=GPXTI13
CONF1.PC14-OSC32_IN\ (PC14).Mode=LSE-External-Oscillator
CONF1.PC14-OSC32_IN\ (PC14).Signal=RCC_OSC32_IN
CONF1.PC15-OSC32_OUT\ (PC15).Mode=LSE-External-Oscillator
CONF1.PC15-OSC32_OUT\ (PC15).Signal=RCC_OSC32_OUT
CONF1.PWR.Dcache1PowerDownInStopMode=PWR_DCACHE1_FULL_STOP_RETENTION
CONF1.PWR.PKA32RAMPowerDownInStopMode=PWR_PKA32RAM_FULL_STOP_RETENTION
CONF1.PWR.PeriphPowerDownInStopMode=PWR_PERIPHRAM_FULL_STOP_RETENTION
CONF1.PWR.PowerMode=PWR_SMPS_SUPPLY
CONF1.PWR.RAM1Page1PowerDownInStopMode=PWR_SRAM1_PAGE1_STOP_RETENTION
CONF1.PWR.RAM1Page2PowerDownInStopMode=PWR_SRAM1_PAGE2_STOP_RETENTION
CONF1.PWR.RAM1Page3PowerDownInStopMode=PWR_SRAM1_PAGE3_STOP_RETENTION
CONF1.PWR.RAM2Page1PowerDownInStopMode=PWR_SRAM2_PAGE1_STOP_RETENTION
CONF1.PWR.RAM2Page2PowerDownInStopMode=PWR_SRAM2_PAGE2_STOP_RETENTION
CONF1.PWR.SRAM4PowerDownInStopMode=__NULL
CONF1.RCC.ADCFreq_Value=16000000
CONF1.RCC.ADF1Freq_Value=4000000
CONF1.RCC.AHBFreq_Value=48000000
CONF1.RCC.APB1Freq_Value=48000000
CONF1.RCC.APB1TimFreq_Value=48000000
CONF1.RCC.APB2Freq_Value=48000000
CONF1.RCC.APB2TimFreq_Value=48000000
CONF1.RCC.APB3Freq_Value=48000000
CONF1.RCC.AdfClockSelection=RCC_ADF1CLKSOURCE_MSIK
CONF1.RCC.CK48CLockSelection=RCC_CLK48CLKSOURCE_MSIK
CONF1.RCC.CK48Freq_Value=4000000
CONF1.RCC.CRSFreq_Value=48000000
CONF1.RCC.CortexFreq_Value=48000000
CONF1.RCC.DACCLockSelectionVirtual=RCC_DAC1CLKSOURCE_LSI
CONF1.RCC.DACCLockSelectionVirtualString=RCC_DAC1CLKSOURCE_LSI
CONF1.RCC.DACFreq_Value=32000
CONF1.RCC.EPOD_VALUE=16000000
CONF1.RCC.FCLKCortexFreq_Value=48000000
CONF1.RCC.FDCANFreq_Value=26666666.666666664
CONF1.RCC.FamilyName=M
CONF1.RCC.HCLKFreq_Value=48000000
CONF1.RCC.HSE_VALUE=16000000
CONF1.RCC.HSI48_VALUE=48000000
CONF1.RCC.HSI_VALUE=16000000
CONF1.RCC.I2C1CLockSelection=RCC_I2C1CLKSOURCE_HSI
CONF1.RCC.I2C1Freq_Value=16000000
CONF1.RCC.I2C2CLockSelection=RCC_I2C2CLKSOURCE_HSI
CONF1.RCC.I2C2Freq_Value=16000000
CONF1.RCC.I2C3CLockSelection=RCC_I2C3CLKSOURCE_HSI
CONF1.RCC.I2C3Freq_Value=16000000
CONF1.RCC.I2C4CLockSelection=RCC_I2C4CLKSOURCE_HSI
CONF1.RCC.I2C4Freq_Value=16000000
CONF1.RCC.LPTIM1CLockSelectionVirtual=RCC_LPTIM1CLKSOURCE_LSE
CONF1.RCC.LPTIM1Freq_Value=32768
CONF1.RCC.LPTIM2CLockSelectionVirtual=RCC_LPTIM2CLKSOURCE_HSI
CONF1.RCC.LPTIM2Freq_Value=16000000
CONF1.RCC.LPUART1CLockSelectionVirtual=RCC_LPUART1CLKSOURCE_HSI
CONF1.RCC.LPUART1Freq_Value=16000000
CONF1.RCC.LSCOPinFreq_Value=32000
CONF1.RCC.LSIDIV_VALUE=32000
CONF1.RCC.LSI_VALUE=32000
CONF1.RCC.MCO1PinFreq_Value=48000000
CONF1.RCC.MDF1Freq_Value=4000000
CONF1.RCC.MSIClockRange=RCC_MSIRANGE_0
CONF1.RCC.MSI_VALUE=48000000
CONF1.RCC.MdfClockSelection=RCC_MDF1CLKSOURCE_MSIK
CONF1.RCC.OCTOSPIMCLockSelection=RCC_OSPICLKSOURCE_MSIK
CONF1.RCC.OCTOSPIMFreq_Value=4000000
CONF1.RCC.PLL1R=1
CONF1.RCC.PLL2PoutputFreq_Value=3096000000
CONF1.RCC.PLL2QoutputFreq_Value=3096000000
CONF1.RCC.PLL2RoutputFreq_Value=3096000000
CONF1.RCC.PLL3PoutputFreq_Value=3096000000
CONF1.RCC.PLL3QoutputFreq_Value=3096000000
CONF1.RCC.PLL3RoutputFreq_Value=3096000000
CONF1.RCC.PLLFRACN=0
CONF1.RCC.PLLM=3
CONF1.RCC.PLLN=10
CONF1.RCC.PLLPoutputFreq_Value=26666666.666666664
CONF1.RCC.PLLQoutputFreq_Value=26666666.666666664
CONF1.RCC.PLLRCLKFreq_Value=53333333.33333333
CONF1.RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSI
CONF1.RCC.RNGCLockSelection=RCC_RNGCLKSOURCE_HSI
CONF1.RCC.RNGFreq_Value=16000000
CONF1.RCC.SAESFreq_Value=48000000
CONF1.RCC.SAI1CLockSelection=RCC_SAI1CLKSOURCE_HSI
CONF1.RCC.SAI1Freq_Value=16000000
CONF1.RCC.SDMMCClockSelection=RCC_SDMMCCLKSOURCE_CLK48
CONF1.RCC.SDMMCFreq_Value=4000000
CONF1.RCC.SPI1CLockSelection=RCC_SPI1CLKSOURCE_HSI
CONF1.RCC.SPI1Freq_Value=16000000
CONF1.RCC.SPI2CLockSelection=RCC_SPI2CLKSOURCE_HSI
CONF1.RCC.SPI2Freq_Value=16000000
CONF1.RCC.SPI3CLockSelection=RCC_SPI3CLKSOURCE_HSI
CONF1.RCC.SPI3Freq_Value=16000000
CONF1.RCC.SYSCLKFreq_VALUE=48000000
CONF1.RCC.UART4CLockSelectionVirtual=RCC_UART4CLKSOURCE_HSI
CONF1.RCC.UART4Freq_Value=16000000
CONF1.RCC.UART5CLockSelectionVirtual=RCC_UART5CLKSOURCE_HSI
CONF1.RCC.UART5Freq_Value=16000000
CONF1.RCC.USART1CLockSelectionVirtual=RCC_USART1CLKSOURCE_HSI
CONF1.RCC.USART1Freq_Value=16000000
CONF1.RCC.USART3CLockSelectionVirtual=RCC_USART3CLKSOURCE_HSI
CONF1.RCC.USART3Freq_Value=16000000
CONF1.RCC.USBFreq_Value=4000000
CONF1.RCC.VCOInput2Freq_Value=48000000
CONF1.RCC.VCOInput3Freq_Value=48000000
CONF1.RCC.VCOInputFreq_Value=5333333.333333333
CONF1.RCC.VCOOutputFreq_Value=53333333.33333333
CONF1.RCC.VCOPLL2OutputFreq_Value=6192000000
CONF1.RCC.VCOPLL3OutputFreq_Value=6192000000
CONF1.SH.GPXTI13.0=GPIO_EXTI13
CONF1.SH.S_LPTIM1_CH1.0=LPTIM1_CH1,OutputIO_CH1
CONF1.ScenarioCount=0
CONF1.VP_ICACHE_VS_ICACHE.Mode=DirectMappedCache
CONF1.VP_ICACHE_VS_ICACHE.Signal=ICACHE_VS_ICACHE
CONF1.VP_LPBAMQUEUE_VS_QUEUE.Mode=QUEUEMODE
CONF1.VP_LPBAMQUEUE_VS_QUEUE.Signal=LPBAMQUEUE_VS_QUEUE
CONF1.VP_LPBAM_VS_SIG1.Mode=SmartRun
CONF1.VP_LPBAM_VS_SIG1.Signal=LPBAM_VS_SIG1
CONF1.VP_LPBAM_VS_SIG4.Mode=LPDMA1
CONF1.VP_LPBAM_VS_SIG4.Signal=LPBAM_VS_SIG4
CONF1.VP_LPDMA1_VS_LPDMACH0.Mode=LINKEDLIST_LPDMACH0
CONF1.VP_LPDMA1_VS_LPDMACH0.Signal=LPDMA1_VS_LPDMACH0
CONF1.VP_LPTIM1_VS_CH1.Mode=Channel_1_Active
CONF1.VP_LPTIM1_VS_CH1.Signal=LPTIM1_VS_CH1
CONF1.VP_LPTIM1_VS_LPTIM_counterModeInternalClock.Mode=Counts__internal_clock_event_00
CONF1.VP_LPTIM1_VS_LPTIM_counterModeInternalClock.Signal=LPTIM1_VS_LPTIM_counterModeInternalClock
CONF1.VP_MEMORYMAP_VS_MEMORYMAP.Mode=CurAppReg
CONF1.VP_MEMORYMAP_VS_MEMORYMAP.Signal=MEMORYMAP_VS_MEMORYMAP
CONF1.VP_PWR_VS_LPOM.Mode=PowerOptimisation
CONF1.VP_PWR_VS_LPOM.Signal=PWR_VS_LPOM
CONF1.VP_PWR_VS_SECSignals.Mode=Security/Privilege
CONF1.VP_PWR_VS_SECSignals.Signal=PWR_VS_SECSignals
CONF1.VP_SYS_VS_Systick.Mode=SysTick
CONF1.VP_SYS_VS_Systick.Signal=SYS_VS_Systick
CONF2.CORTEX_M33_NS.userName=CORTEX_M33
CONF2.ConfName=LpbamAp1
CONF2.File.Version=6
CONF2.GPIO.groupedBy=Group By Peripherals
CONF2.KeepUserPlacement=false
CONF2.MMTAppRegionsCount=0
CONF2.MMTConfigApplied=false
CONF2.Mcu.CPN=STM32U545RET6Q
CONF2.Mcu.ContextProject=TrustZoneDisabled
CONF2.Mcu.Family=STM32U5
CONF2.Mcu.IP0=CORTEX_M33_NS
CONF2.Mcu.IP1=LPBAM
CONF2.Mcu.IP2=LPBAMQUEUE
CONF2.Mcu.IP3=MEMORYMAP
CONF2.Mcu.IP4=NVIC
CONF2.Mcu.IP5=RCC
CONF2.Mcu.IP6=SYS
CONF2.Mcu.IPNb=7
CONF2.Mcu.Name=STM32U545RETxQ
CONF2.Mcu.Package=LQFP64
CONF2.Mcu.Pin0=VP_LPBAMQUEUE_VS_QUEUE
CONF2.Mcu.Pin1=VP_SYS_VS_Systick
CONF2.Mcu.Pin2=VP_LPBAM_VS_SIG1
CONF2.Mcu.Pin3=VP_LPBAM_VS_SIG4
CONF2.Mcu.Pin4=VP_MEMORYMAP_VS_MEMORYMAP
CONF2.Mcu.PinsNb=5
CONF2.Mcu.ThirdPartyNb=0
CONF2.Mcu.UserConstants=LPDP,320U;LPDR,0U;LPDPU,160U
CONF2.Mcu.UserName=STM32U545RETxQ
CONF2.MultiConf.Active=LpbamAp1
CONF2.MultiConf.NbConfig=2
CONF2.MxCube.Version=6.11.0
CONF2.MxDb.Version=DB.6.0.110
CONF2.NVIC.ForceEnableDMAVector=true
CONF2.NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
CONF2.PinOutPanel.RotationAngle=0
CONF2.RCC.ADCFreq_Value=16000000
CONF2.RCC.CRSFreq_Value=48000000
CONF2.RCC.DACCLockSelectionVirtual=RCC_DAC1CLKSOURCE_LSI
CONF2.RCC.DACCLockSelectionVirtualString=RCC_DAC1CLKSOURCE_LSI
CONF2.RCC.DACFreq_Value=32000
CONF2.RCC.EPOD_VALUE=4000000
CONF2.RCC.FDCANFreq_Value=258000000
CONF2.RCC.FamilyName=M
CONF2.RCC.HSE_VALUE=16000000
CONF2.RCC.HSI48_VALUE=48000000
CONF2.RCC.HSI_VALUE=16000000
CONF2.RCC.I2C1Freq_Value=16000000
CONF2.RCC.I2C2Freq_Value=16000000
CONF2.RCC.I2C3Freq_Value=16000000
CONF2.RCC.I2C4Freq_Value=16000000
CONF2.RCC.LPTIM2Freq_Value=16000000
CONF2.RCC.LPUART1Freq_Value=16000000
CONF2.RCC.LSCOPinFreq_Value=32000
CONF2.RCC.LSE_VALUE=32768
CONF2.RCC.LSIDIV_VALUE=32000
CONF2.RCC.LSI_VALUE=32000
CONF2.RCC.MSI_VALUE=4000000
CONF2.RCC.PLL2PoutputFreq_Value=258000000
CONF2.RCC.PLL2QoutputFreq_Value=258000000
CONF2.RCC.PLL2RoutputFreq_Value=258000000
CONF2.RCC.PLL3PoutputFreq_Value=258000000
CONF2.RCC.PLL3QoutputFreq_Value=258000000
CONF2.RCC.PLL3RoutputFreq_Value=258000000
CONF2.RCC.PLLPoutputFreq_Value=258000000
CONF2.RCC.PLLQoutputFreq_Value=258000000
CONF2.RCC.PLLRCLKFreq_Value=258000000
CONF2.RCC.RNGFreq_Value=16000000
CONF2.RCC.SAESFreq_Value=48000000
CONF2.RCC.SAI1Freq_Value=16000000
CONF2.RCC.SPI1Freq_Value=16000000
CONF2.RCC.SPI2Freq_Value=16000000
CONF2.RCC.SPI3Freq_Value=16000000
CONF2.RCC.UART4Freq_Value=16000000
CONF2.RCC.UART5Freq_Value=16000000
CONF2.RCC.USART1Freq_Value=16000000
CONF2.RCC.USART3Freq_Value=16000000
CONF2.RCC.USBFreq_Value=4000000
CONF2.RCC.VCOInput2Freq_Value=4000000
CONF2.RCC.VCOInput3Freq_Value=4000000
CONF2.RCC.VCOInputFreq_Value=4000000
CONF2.RCC.VCOOutputFreq_Value=516000000
CONF2.RCC.VCOPLL2OutputFreq_Value=516000000
CONF2.RCC.VCOPLL3OutputFreq_Value=516000000
CONF2.S1.Q1.F1.FuncUserName=Start_1
CONF2.S1.Q1.F1.FuncVirtualPinList=VP_LPBAMLPTIM1_VS_START
CONF2.S1.Q1.F1.IpInstanceName=LPBAMLPTIM1
CONF2.S1.Q1.F1.LPBAMLPTIM1.NodeLevel_START=LPBAM_LPTIM_START_FULLQ_CONFIG_NODE
CONF2.S1.Q1.F1.LPBAMLPTIM1.StartMode_START=LPBAM_LPTIM_START_CONTINUOUS
CONF2.S1.Q1.F1.VP_LPBAMLPTIM1_VS_START.Mode=START
CONF2.S1.Q1.F1.VP_LPBAMLPTIM1_VS_START.Signal=LPBAMLPTIM1_VS_START
CONF2.S1.Q1.F2.FuncUserName=PWM_1
CONF2.S1.Q1.F2.FuncVirtualPinList=VP_LPBAMLPTIM1_VS_PWM
CONF2.S1.Q1.F2.IpInstanceName=LPBAMLPTIM1
CONF2.S1.Q1.F2.LPBAMLPTIM1.CircularNode_PWM=LPBAM_LPTIM_PWM_FULLQ_CONFIG_NODE
CONF2.S1.Q1.F2.LPBAMLPTIM1.NodeLevel_PWM=LPBAM_LPTIM_PWM_FULLQ_CONFIG_NODE
CONF2.S1.Q1.F2.LPBAMLPTIM1.PeriodValue_PWM=3270
CONF2.S1.Q1.F2.LPBAMLPTIM1.PulseValue_PWM=1630
CONF2.S1.Q1.F2.LPBAMLPTIM1.UpdatePeriod_PWM=ENABLE
CONF2.S1.Q1.F2.LPBAMLPTIM1.UpdatePulse_PWM=ENABLE
CONF2.S1.Q1.F2.VP_LPBAMLPTIM1_VS_PWM.Mode=PWM
CONF2.S1.Q1.F2.VP_LPBAMLPTIM1_VS_PWM.Signal=LPBAMLPTIM1_VS_PWM
CONF2.S1.Q1.F3.FuncUserName=Write_Pin_1
CONF2.S1.Q1.F3.FuncVirtualPinList=VP_LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F3.IpInstanceName=LPBAMLPGPIO1
CONF2.S1.Q1.F3.LPBAMLPGPIO1.NodeLevel-WRITEPIN=LPBAM_GPIO_WRITEPIN_FULLQ_DATA_NODE
CONF2.S1.Q1.F3.LPBAMLPGPIO1.PinState_WRITEPIN=LPBAM_GPIO_PIN_SET
CONF2.S1.Q1.F3.LPBAMLPGPIO1.TriggerPolarity=LPBAM_DMA_TRIG_POLARITY_RISING
CONF2.S1.Q1.F3.LPBAMLPGPIO1.TriggerSelection=LPBAM_LPDMA1_TRIGGER_LPTIM1_CH1
CONF2.S1.Q1.F3.VP_LPBAMLPGPIO1_VS_WRITEPIN.Mode=WRITEPIN
CONF2.S1.Q1.F3.VP_LPBAMLPGPIO1_VS_WRITEPIN.Signal=LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F4.FuncUserName=Write_Pin_2
CONF2.S1.Q1.F4.FuncVirtualPinList=VP_LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F4.IpInstanceName=LPBAMLPGPIO1
CONF2.S1.Q1.F4.LPBAMLPGPIO1.NodeLevel-WRITEPIN=LPBAM_GPIO_WRITEPIN_FULLQ_DATA_NODE
CONF2.S1.Q1.F4.LPBAMLPGPIO1.TriggerPolarity=LPBAM_DMA_TRIG_POLARITY_RISING
CONF2.S1.Q1.F4.LPBAMLPGPIO1.TriggerSelection=LPBAM_LPDMA1_TRIGGER_LPTIM1_CH1
CONF2.S1.Q1.F4.VP_LPBAMLPGPIO1_VS_WRITEPIN.Mode=WRITEPIN
CONF2.S1.Q1.F4.VP_LPBAMLPGPIO1_VS_WRITEPIN.Signal=LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F5.FuncUserName=PWM_2
CONF2.S1.Q1.F5.FuncVirtualPinList=VP_LPBAMLPTIM1_VS_PWM
CONF2.S1.Q1.F5.IpInstanceName=LPBAMLPTIM1
CONF2.S1.Q1.F5.LPBAMLPTIM1.NodeLevel_PWM=LPBAM_LPTIM_PWM_FULLQ_CONFIG_NODE
CONF2.S1.Q1.F5.LPBAMLPTIM1.PeriodValue_PWM=1630
CONF2.S1.Q1.F5.LPBAMLPTIM1.PulseValue_PWM=815
CONF2.S1.Q1.F5.LPBAMLPTIM1.UpdatePeriod_PWM=ENABLE
CONF2.S1.Q1.F5.LPBAMLPTIM1.UpdatePulse_PWM=ENABLE
CONF2.S1.Q1.F5.VP_LPBAMLPTIM1_VS_PWM.Mode=PWM
CONF2.S1.Q1.F5.VP_LPBAMLPTIM1_VS_PWM.Signal=LPBAMLPTIM1_VS_PWM
CONF2.S1.Q1.F6.FuncUserName=Write_Pin_3
CONF2.S1.Q1.F6.FuncVirtualPinList=VP_LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F6.IpInstanceName=LPBAMLPGPIO1
CONF2.S1.Q1.F6.LPBAMLPGPIO1.NodeLevel-WRITEPIN=LPBAM_GPIO_WRITEPIN_FULLQ_DATA_NODE
CONF2.S1.Q1.F6.LPBAMLPGPIO1.PinState_WRITEPIN=LPBAM_GPIO_PIN_SET
CONF2.S1.Q1.F6.LPBAMLPGPIO1.TriggerPolarity=LPBAM_DMA_TRIG_POLARITY_RISING
CONF2.S1.Q1.F6.LPBAMLPGPIO1.TriggerSelection=LPBAM_LPDMA1_TRIGGER_LPTIM1_CH1
CONF2.S1.Q1.F6.VP_LPBAMLPGPIO1_VS_WRITEPIN.Mode=WRITEPIN
CONF2.S1.Q1.F6.VP_LPBAMLPGPIO1_VS_WRITEPIN.Signal=LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F7.FuncUserName=Write_Pin_4
CONF2.S1.Q1.F7.FuncVirtualPinList=VP_LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.F7.IpInstanceName=LPBAMLPGPIO1
CONF2.S1.Q1.F7.LPBAMLPGPIO1.NodeLevel-WRITEPIN=LPBAM_GPIO_WRITEPIN_FULLQ_DATA_NODE
CONF2.S1.Q1.F7.LPBAMLPGPIO1.TriggerPolarity=LPBAM_DMA_TRIG_POLARITY_RISING
CONF2.S1.Q1.F7.LPBAMLPGPIO1.TriggerSelection=LPBAM_LPDMA1_TRIGGER_LPTIM1_CH1
CONF2.S1.Q1.F7.VP_LPBAMLPGPIO1_VS_WRITEPIN.Mode=WRITEPIN
CONF2.S1.Q1.F7.VP_LPBAMLPGPIO1_VS_WRITEPIN.Signal=LPBAMLPGPIO1_VS_WRITEPIN
CONF2.S1.Q1.FuncCount=7
CONF2.S1.Q1.FuncLastActive=F7
CONF2.S1.Q1.IpInstanceName=LPBAMQUEUE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt1=DMA_IT_DTE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt2=DMA_IT_ULE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt3=DMA_IT_USE
CONF2.S1.Q1.LPBAMQUEUE.Interrupt5=DMA_IT_TC
CONF2.S1.Q1.LPBAMQUEUE.Interrupt6=DMA_IT_TO
CONF2.S1.Q1.QueueCircularity=1
CONF2.S1.Q1.QueueUserName=GPIOState
CONF2.S1.Q1.QueueVirtualPinList=VP_LPBAMQUEUE_VS_QUEUE
CONF2.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Mode=QUEUEMODE
CONF2.S1.Q1.VP_LPBAMQUEUE_VS_QUEUE.Signal=LPBAMQUEUE_VS_QUEUE
CONF2.S1.QueueCount=1
CONF2.S1.QueueLastActive=Q1
CONF2.S1.ScenarioName=TrigGPIO
CONF2.ScenarioCount=1
CONF2.VP_LPBAM_VS_SIG1.Mode=SmartRun
CONF2.VP_LPBAM_VS_SIG1.Signal=LPBAM_VS_SIG1
CONF2.VP_LPBAM_VS_SIG4.Mode=LPDMA1
CONF2.VP_LPBAM_VS_SIG4.Signal=LPBAM_VS_SIG4
CONF2.VP_MEMORYMAP_VS_MEMORYMAP.Mode=CurAppReg
CONF2.VP_MEMORYMAP_VS_MEMORYMAP.Signal=MEMORYMAP_VS_MEMORYMAP
CONF2.VP_SYS_VS_Systick.Mode=SysTick
CONF2.VP_SYS_VS_Systick.Signal=SYS_VS_Systick
CONF2.board=NUCLEO-U545RE-Q
CONF2.boardIOC=true
CONF2.isbadioc=true
Mcu.Family=STM32U5
Mcu.Name=STM32U545RETxQ
Mcu.Package=LQFP64
Mcu.UserConstants=LPDP,320U;LPDR,0U;LPDPU,160U
MultiConf.NbConfig=2
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
board=NUCLEO-U545RE-Q

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2024 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

void SystemClock_Config(void);
static void SystemPower_Config(void);
static void MX_GPIO_Init(void);
static void MX_ICACHE_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Configure the System Power */
  SystemPower_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();
  MX_ICACHE_Init();

  /* Infinite loop */
  while (1)
  {

  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  if (HAL_PWREx_ControlVoltageScaling(PWR_REGULATOR_VOLTAGE_SCALE4) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_MSI;
  RCC_OscInitStruct.MSIState = RCC_MSI_ON;
  RCC_OscInitStruct.MSICalibrationValue = RCC_MSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.MSIClockRange = RCC_MSIRANGE_4;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2
                              |RCC_CLOCKTYPE_PCLK3;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_MSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB3CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

/**
  * @brief Power Configuration
  * @retval None
  */
static void SystemPower_Config(void)
{

  /*
   * Switch to SMPS regulator instead of LDO
   */
  if (HAL_PWREx_ConfigSupply(PWR_SMPS_SUPPLY) != HAL_OK)
  {
    Error_Handler();
  }
}

static void MX_ICACHE_Init(void)
{

  /** Enable instruction cache in 1-way (direct mapped cache)
  */
  if (HAL_ICACHE_ConfigAssociativityMode(ICACHE_1WAY) != HAL_OK)
  {
    Error_Handler();
  }
  if (HAL_ICACHE_Enable() != HAL_OK)
  {
    Error_Handler();
  }

}

static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOC_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(LED_GREEN_GPIO_Port, LED_GREEN_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pin : USER_BUTTON_Pin */
  GPIO_InitStruct.Pin = USER_BUTTON_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_IT_FALLING;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(USER_BUTTON_GPIO_Port, &GPIO_InitStruct);

  /*Configure GPIO pin : LED_GREEN_Pin */
  GPIO_InitStruct.Pin = LED_GREEN_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
  HAL_GPIO_Init(LED_GREEN_GPIO_Port, &GPIO_InitStruct);

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
